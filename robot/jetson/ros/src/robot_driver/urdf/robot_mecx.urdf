Commit message: 跑通了gmapping建图导航

File: robot/jetson/ros/src/robot_driver/urdf/robot_mecx.urdf (robot description, URDF)
Before this commit: robot robot_mecx, 1 links, 0 joints
Links:
- link base_footprint: geometry visual mesh filename=package://robot_driver/urdf/MECX1.STL
